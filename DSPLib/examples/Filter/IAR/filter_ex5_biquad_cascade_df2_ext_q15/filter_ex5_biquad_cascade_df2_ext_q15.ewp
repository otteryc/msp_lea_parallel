# IAR project filter_ex5_biquad_cascade_df2_ext_q15.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430xlsfn.h
  General.OGChipSelectMenu: MSP430FR5994 MSP430FR5994
  General.GStackSize2: 160
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: ..\..\..\..\include
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  General.GStackSize2: 80
  General.GHeapSize2: 80
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  ICC430.ADefines: NDEBUG
  group (top)
    ../../: filter_ex5_biquad_cascade_df2_ext_q15.c
  group dsplib/include
    ../../../../include/: DSPLib.h DSPLib_filter.h DSPLib_lea.h DSPLib_matrix.h DSPLib_support.h DSPLib_transform.h DSPLib_types.h DSPLib_utility.h DSPLib_vector.h
  group dsplib/source/filter
    ../../../../source/filter/: msp_biquad_df1_q15.c msp_biquad_df2_q15.c msp_biquad_df2_ext_q15.c msp_biquad_cascade_df1_q15.c msp_biquad_cascade_df2_ext_q15.c msp_biquad_cascade_df2_q15.c msp_cmplx_fir_iq31.c msp_cmplx_fir_q15.c msp_fir_iq31.c msp_fir_q15.c
  group dsplib/source/lea
    ../../../../source/lea/: msp_lea_flags.c msp_lea_init.c msp_lea_isr.c msp_lea_patch.c
  group dsplib/source/matrix
    ../../../../source/matrix/: msp_matrix_abs_iq31.c msp_matrix_abs_q15.c msp_matrix_add_iq31.c msp_matrix_add_q15.c msp_matrix_mpy_iq31.c msp_matrix_mpy_q15.c msp_matrix_neg_iq31.c msp_matrix_neg_q15.c msp_matrix_offset_iq31.c msp_matrix_offset_q15.c msp_matrix_scale_iq31.c msp_matrix_scale_q15.c msp_matrix_shift_iq31.c msp_matrix_shift_q15.c msp_matrix_sub_iq31.c msp_matrix_sub_q15.c msp_matrix_trans_iq31.c msp_matrix_trans_q15.c
  group dsplib/source/transform
    ../../../../source/transform/: msp_cmplx_bitrev_iq31.c msp_cmplx_bitrev_q15.c msp_cmplx_fft_auto_q15.c msp_cmplx_fft_fixed_q15.c msp_cmplx_fft_iq31.c msp_cmplx_ifft_auto_q15.c msp_cmplx_ifft_fixed_q15.c msp_cmplx_ifft_iq31.c msp_fft_auto_q15.c msp_fft_fixed_q15.c msp_fft_iq31.c msp_ifft_auto_q15.c msp_ifft_fixed_q15.c msp_ifft_iq31.c msp_split_iq31.c msp_split_q15.c msp_transform_tables.c
  group dsplib/source/utility
    ../../../../source/utility/: msp_cmplx_fill_iq31.c msp_cmplx_fill_q15.c msp_copy_iq31.c msp_copy_q15.c msp_deinterleave_iq31.c msp_deinterleave_q15.c msp_fill_iq31.c msp_fill_q15.c msp_sinusoid_q15.c msp_interleave_q15.c msp_interleave_iq31.c msp_q15_to_iq31.c msp_sinusoid_q15.c msp_cmplx_q15.c msp_cmplx_iq31.c
  group dsplib/source/vector
    ../../../../source/vector/: msp_abs_iq31.c msp_abs_q15.c msp_add_iq31.c msp_add_q15.c msp_cmplx_add_iq31.c msp_cmplx_add_q15.c msp_cmplx_conj_iq31.c msp_cmplx_conj_q15.c msp_cmplx_mac_iq31.c msp_cmplx_mac_q15.c msp_cmplx_mpy_iq31.c msp_cmplx_mpy_q15.c msp_cmplx_mpy_real_iq31.c msp_cmplx_mpy_real_q15.c msp_cmplx_scale_iq31.c msp_cmplx_scale_q15.c msp_cmplx_shift_iq31.c msp_cmplx_shift_q15.c msp_cmplx_sub_iq31.c msp_cmplx_sub_q15.c msp_mac_iq31.c msp_mac_q15.c msp_max_iq31.c msp_max_q15.c msp_max_uq15.c msp_max_uq31.c msp_min_iq31.c msp_min_q15.c msp_min_uq15.c msp_min_uq31.c msp_mpy_iq31.c msp_mpy_q15.c msp_neg_iq31.c msp_neg_q15.c msp_offset_iq31.c msp_offset_q15.c msp_scale_iq31.c msp_scale_q15.c msp_shift_iq31.c msp_shift_q15.c msp_sub_iq31.c msp_sub_q15.c
